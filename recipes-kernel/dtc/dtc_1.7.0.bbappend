BUILD_CFLAGS:append:class-native = " -Wno-error=discarded-qualifiers"
