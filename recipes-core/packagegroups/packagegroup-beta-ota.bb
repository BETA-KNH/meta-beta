DESCRIPTION = "OTA update packages for Beta OS"

LICENSE = "MIT"

inherit packagegroup

