SRC_URI += "file://0001-bootdelay.patch"
