# TODO: fix it so this u-boot setting is applied
BOOTDELAY = "-2"
