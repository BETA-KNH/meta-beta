FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0002-threads-Fix-glibc-C11-threading-conflict.patch"
