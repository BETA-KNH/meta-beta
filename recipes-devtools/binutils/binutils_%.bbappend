EXTRA_OECONF:append:class-native = " --disable-gprofng"
