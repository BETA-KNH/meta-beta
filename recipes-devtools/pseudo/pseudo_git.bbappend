FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-openat2-use-const-open_how-pointer.patch"
